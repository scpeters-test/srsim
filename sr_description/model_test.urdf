Commit message: gain params.

File: sr_description/model_test.urdf (robot description, URDF)
Before this commit: robot arm_and_hand, 32 links, 31 joints
Links:
- removed link shadowarm_handsupport
Joints:
- removed joint arm_link
- joint arm_base_joint: child shadowarm_handsupport -> forearm
